# IAR project TWTDCEmbedded.ewp, settings and files
configuration at91sam9260_sdram (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9260 Atmel AT91SAM9260
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: at91sam9260; sdram; TRACE_LEVEL=0; BeamOnDBG=0; BeamOffDBG=2; ScalarMode=0
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\at91lib/peripherals; ..\at91lib; ..\at91lib/boards/at91sam9260-ek
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam9260; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\at91lib; ..\at91lib\peripherals; ..\at91lib\boards\at91sam9260-ek
  OBJCOPY.OOCOutputFile: TWTDCEmbedded.bin
  ILINK.IlinkOutputFile: TWTDCEmbedded.out
  ILINK.IlinkIcfFile: ..\at91lib/boards/at91sam9260-ek/at91sam9260/sdram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group (top)
    ./: main.c
  group at91lib/boards/at91sam9260-ek
    ../at91lib/boards/at91sam9260-ek/: board.h board_cstartup_iar.s board_lowlevel.c board_memories.c board_memories.h
  group at91lib/boards/at91sam9260-ek/at91sam9260
    ../at91lib/boards/at91sam9260-ek/at91sam9260/: AT91SAM9260.h norflash.icf sdram.icf sram.icf
  group at91lib/peripherals/aic
    ../at91lib/peripherals/aic/: aic.c aic.h
  group at91lib/peripherals/cp15
    ../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/pio
    ../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pit
    ../at91lib/peripherals/pit/: pit.c pit.h
  group at91lib/peripherals/pmc
    ../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/tc
    ../at91lib/peripherals/tc/: tc.c tc.h
  group at91lib/utility
    ../at91lib/utility/: assert.h led.c led.h trace.h
  group resources
    ../../../../IAR Embedded Workbench/getting-started-project-at91sam9260-ek-tek/resources/iar/: at91cap9-dk-bcram.mac at91cap9-dk-ddram.mac at91cap9-dk-sdram.mac at91cap9-dk-sram.mac at91cap9-stk-sdram.mac at91cap9-stk-sram.mac at91sam7a3-ek-flash.mac at91sam7a3-ek-sram.mac at91sam7l-ek-flash.mac at91sam7l-stk-flash.mac at91sam7s-ek-flash.mac at91sam7s-ek-sram.mac at91sam7se-ek-flash.mac at91sam7se-ek-sdram.mac at91sam7se-ek-sram.mac at91sam7x-ek-flash.mac at91sam7x-ek-sram.mac at91sam7xc-ek-flash.mac at91sam7xc-ek-sram.mac at91sam9260-ek-norflash.mac at91sam9260-ek-sdram.mac at91sam9260-ek-sram.mac at91sam9261-ek-norflash.mac at91sam9261-ek-sdram.mac at91sam9261-ek-sram.mac at91sam9263-ek-sdram.mac at91sam9263-ek-sram.mac at91sam9g20-ek-norflash.mac at91sam9g20-ek-sdram.mac at91sam9g20-ek-sram.mac at91sam9m10-ek-ddram.mac at91sam9m10-ek-sram.mac at91sam9rl-ek-sdram.mac at91sam9rl-ek-sram.mac at91sam9xe-ek-flash.mac at91sam9xe-ek-sdram.mac at91sam9xe-ek-sram.mac
